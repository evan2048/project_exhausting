# Keil uVision project STM32L031K6T6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L031K6T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L031xx,USE_FULL_LL_DRIVER
  c include: ./;../Inc;../STM32L0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK-ARM
    ./: startup_stm32l031xx.s
  group Inc
    ../Inc/: main.h stm32_assert.h stm32l0xx_it.h
  group Src
    ../Src/: main.c stm32l0xx_it.c system_stm32l0xx.c
  group STM32L0xx_HAL_Driver
    ../STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_utils.c stm32l0xx_ll_gpio.c
software components: CMSIS:CORE 5.3.0
